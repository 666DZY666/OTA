# Keil uVision project mcu_stm32f103c8x.uvprojx, settings and files
target mcu_stm32f103c8x (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: mcu_stm32f103c8x +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c misc: --c99
  c include: ..\Lib\STM32F10x_StdPeriph_Driver\inc;..\Lib\CMSIS\CM3\CoreSupport;..\Lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\User;..\Hal;..\Gizwits;..\Utils;..\Hal\Hal_rgb_led;..\Hal\Hal_led;..\Hal\Hal_key;..\Hal\hal_motor;..\SYSTEM\delay;..\SYSTEM\usart;..\SYSTEM\sys;..\Hal\TIMER
  library: MicroLIB
  memory RVCT4: ROM 0x8003000 size 0x6800
  memory RVCT9: RAM 0x20000000 size 0x5000
  group StartUp
    ../Lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group CMSIS
    ../Lib/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Lib
    ../Lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group User
    ../Hal/Hal_Usart/: hal_uart.c
    ../User/: main.c
    ../User/md5/: gagent_md5.c
  group Hal
    ../User/: stm32f10x_it.c
    ../Hal/Hal_key/: hal_key.c
    ../Hal/Hal_Watchdog/: hal_watchdog.c
    ../Hal/Hal_Flash/: Flash.c
    ../Hal/Hal_rgb_led/: hal_rgb_led.c
    ../Hal/Hal_led/: Hal_led.c
    ../Hal/hal_motor/: hal_motor.c
    ../Hal/TIMER/: timer.c
  group Gizwits
    ../Gizwits/: gizwits_product.c gizwits_protocol.c
  group Utils
    ../Utils/: common.c dataPointTools.c ringbuffer.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
software components: CMSIS:CORE 5.0.1
